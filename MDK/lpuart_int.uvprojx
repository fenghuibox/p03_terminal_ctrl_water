# Keil uVision project lpuart_int.uvprojx, settings and files
target lpuart_int_Release (6070000::V6.7::.\ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ESEL ELITTLE
  output: lpuart_int +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: .\..\mcu\common;.\..\driver\inc;.\..\source;.\..\com;.\..\dri;.\..\mod;.\..\mod_timer;.\..\uart_pack;.\..\mod_dbg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l17x.s
    ../mcu/common/: interrupts_hc32l17x.c system_hc32l17x.c
  group source
    ../source/: main.c
  group driver
    ../driver/src/: adc.c ddl.c flash.c gpio.c lpm.c lpuart.c reset.c rtc.c sysctrl.c lptim.c bt.c
  group README
    ../: readme.txt
  group com
    ../com/: com_atoi.c com_bit.c com_buf.c com_char.c com_delay.c com_list.c com_mac.c com_memory.c com_queue.c com_queue_val_len.c com_sqList.c com_str.c com_var.c
  group dri
    ../dri/: dri.c dri_clk.c dri_timer.c dri_uart_debug.c
  group mod_timer
    ../mod_timer/: timer.c
  group uart_pack
    ../uart_pack/: uart_pack.c
  group mod_dbg
    ../mod_dbg/: dbg.c dbg_uart.c dbg_cmd.c dbg_cmd_aes.c dbg_cmd_dev.c dbg_cmd_uart_pass.c
  group mod
    ../mod/: mod.c
software components: CMSIS:CORE 4.1.0
